# Repository bjthemost-hub/OC730_BOOST_PROT

File README.md:

# OC730_BOOST_PROT

升压变换器的隔离式**过压 / 过温保护网络**: 二次侧 SVCC 过压或板温过高时, 把一次侧的 `SNSBOOST`
节点经 Q730 短接到 PGND, 让升压控制器关断。两侧只经 OC730 光耦相联, PGND 与 AGND 分开。

## 仓库内容

- `kicad/OC730_BOOST_PROT/` —— KiCad 10 工程: 原理图 `.kicad_sch`、PCB `.kicad_pcb`、工程设置、自建符号库 `OC730PWR`。
- 原理分析、BOM、PDF、生成脚本、工作报告**不在 GitHub 上**, 在自家 Gitea:
  `ssh://gitea/zhougx/OC730_BOOST_PROT.git`

## 假定的电源条件(都是假设, 不是实测)

原图没有标注任何电压, 下面几条是算阻值和门限时**自己假定**的前提, 板子上没有量过:

| 量 | 假定值 |
|---|---|
| PVCC | 12 V |
| SVCC | 24 V |
| SVCC 过压门限 | ≈ 31 V |
| 过温点 | ≈ 100 °C |
| 光耦 LED 正向压降 Vf | ≈ 1.2 V |
| NTC | R25 = 10 kΩ / B = 3950 |

图里那组 1k / 120R / 470R / 680R / 20V 就是按上表算出的**估算起手值, 未实测**; 实际电压不是这两个数, 阻值全部要重算。

## 注意

原图没有标任何阻值和 D730 稳压值。原图 Q730 的 2=D / 3=S 与 SOT-23 实际(1=G, 2=S, 3=D)不一致, 本图按 2N7002 实际封装画, 打板前再核一遍。

## KiCad design kicad/OC730_BOOST_PROT/OC730_BOOST_PROT.kicad_pcb

Parts:
D730: BZT52C20(12V); D_SOD-123
OC730: PC817; SMDIP-4_W7.62mm; MPN PC817X3CSP9F; LCSC C41807
Q730: 2N7002; SOT-23; MPN 2N7002; LCSC C8545
R733, R734, R735, R736: TBD; R_0805_2012Metric
RV730: NTC 10k B3950; R_0603_1608Metric; MPN SDNT1608X103J3950HTF; LCSC C92367

Connections:
AGND: D730.2 (A)
unnamed: D730.1 (K), OC730.2, R734.2
unnamed: OC730.1, R733.2, R734.1
unnamed: OC730.4, R736.2, RV730.1
unnamed: OC730.3, Q730.1 (G), R735.1, RV730.2
PGND: Q730.2 (S), R735.2
PVCC: R736.1
SNSBOOST: Q730.3 (D)
SVCC: R733.1

Notes on the sheet:
2. 三条支路怎么动作
(d) OC730 是位号(不是型号); 按 DIP-4 / SMDIP-4 的 PC817 类光耦选型(1=A, 2=K, 3=E, 4=C)。
一次侧 · PVCC / PGND
二次侧(SVCC)过压、或板温过高时, 把一次侧的 SNSBOOST 节点经 Q730 短接到 PGND, 让升压(boost)关断。
(c) SNSBOOST 在目标 IC 上是反馈 / 电流检测 / 使能, 原图没有 IC 可查; 拉到地是关断还是限流以该 IC 手册为准。
(a) 全部阻值与 D730 稳压值: 原图未标 -> 本页写 TBD; 门限公式与估算起手值见 docs 的分析文档。
(b) 原图 Q730 标 2=D / 3=S, 与 SOT-23 的 1=G,2=S,3=D 不一致; 本页按 2N7002 实际封装脚序画,
(b) 过温: RV730 是 NTC, 与光敏管并联在 A 点与栅极节点之间; 温度升 -> 阻值降 -> 栅极电压升高。
3. 原图没给、需要核实的几处
压降超过 LED 正向压降后 OC730 的 LED(1-2) 起辉, 光敏管(4-3) 导通, 把栅极节点拉向 A 点。
(c) 关断: 栅极超过 Q730 的 Vth -> Q730 导通 -> SNSBOOST 短接到 PGND -> 升压关断。
R736 既是 A 点的限流电阻, 也与 RV730 / R735 组成栅极分压; R735 是栅极下拉, 无故障时保证 Q730 关断。
(a) 过压: SVCC-R733-[C]-R734-[D]-D730(齐纳)-AGND。R734 上的压降 = I x R734;
1. 这块电路是干什么的
二次侧 · SVCC / AGND
打板前按所选封装核对一遍脚序。
两个故障源分别经 OC730 光耦 / RV730 热敏电阻作用到 Q730 的栅极; 两侧只经光耦相联, PGND 与 AGND 分开。
图片来自网络,如有侵权请告知

Board: 2 copper layers, 19.7 x 14.5 mm, 8 parts (0 on the bottom side), 5 nets.
